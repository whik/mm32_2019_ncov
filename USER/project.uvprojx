# Keil uVision project project.uvprojx, settings and files
target MM32W3xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32W373PSB MindMotion
  pack: MindMotion.MM32W3xxB_DFP.1.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flash +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER DEVICE_INFO_SUPPORT USE_UART
  c include: ..\CMSIS;..\HAL\inc;..\HARDWARE;..\SYSTEM;..\USER;..\MALLOC;..\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c
    ./: main.h config.h
  group CMSIS
    ../CMSIS/: HAL_device.h MM32W3xx.h startup_MM32W3xx.s system_MM32W3xx.c SYSTEM_MM32W3xx.h
  group SYSTEM
    ../SYSTEM/: delay.c
  group HARDWARE
    ../HARDWARE/: drv_led.c drv_key.c drv_timer.c drv_lcd.c drv_lcd_gui.c drv_uart1.c drv_uart2.c
  group HAL
    ../HAL/src/: HAL_gpio.c HAL_misc.c HAL_rcc.c HAL_uart.c HAL_tim.c HAL_exti.c
  group ESP8266
    ../ESP8266/: ncov_data.c wifista.c cJSON.c
  group MALLOC
    ../MALLOC/: malloc.c
  group DOC
    ../: README.md
